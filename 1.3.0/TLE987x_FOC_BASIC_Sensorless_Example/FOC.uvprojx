# Keil uVision project FOC.uvprojx, settings and files
target Target 1 (6130001::V6.13.1::ARMCLANG)
  device: TLE9879QXA40 Infineon
  pack: Infineon.TLE987x_DFP.1.5.0
  cpu: IRAM(0x18000018,0x17E8) IRAM2(0x18000000,0x10) IROM(0x11000000,0x1EFFC) IROM2(0x1101EFFC,0x1004) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: FOC
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: .\MHA\include;.\Math\include;.\MAS\include;.\MS\include;.\MDA\include;.\Probescope\include;.\util
  library: MicroLIB
  memory RVCT4: ROM 0x11000000 size 0x1effc
  memory RVCT5: ROM 0x1101effc size 0x1004
  memory RVCT9: RAM 0x18000018 size 0x17e8
  memory RVCT10: RAM 0x18000000 size 0x10
  scatter file: .\Objects\FOC.sct
  group Example
    ./Example/: main.c
  group Probescope
    ./Probescope/src/: probe_scope.c
software components: CMSIS:CORE 5.3.0, CMSIS:DSP 1.7.0, Device:BF-Stepping 0.0.1, Device:ConfigWizard_v2 2.1.12, Device:SDK:ADC1 0.2.8, Device:SDK:ADC2 0.2.5, Device:SDK:BDRV 0.4.8, Device:SDK:BOOTROM 0.3.0, Device:SDK:CCU6 0.3.2, Device:SDK:CSA 0.1.7, Device:SDK:DMA 0.2.2, Device:SDK:GPT12E 0.2.0, Device:SDK:INT 0.2.2, Device:SDK:ISR 0.2.8, Device:SDK:LIN 0.1.9, Device:SDK:PMU 0.2.0, Device:SDK:PORT 0.5.7, Device:SDK:SCU 0.5.4, Device:SDK:SSC 0.1.7, Device:SDK:TIMER3 0.1.7, Device:SDK:UART 0.2.2, Device:SDK:WDT1 0.3.2, Device:Startup 1.1.0, TLE987x-eSL-BAS-EVAL:MAS-BAS_v1.3.0-PR 1.3.0, TLE987x-eSL-BAS-EVAL:MDA-BAS_v1.3.0-PR 1.3.0, TLE987x-eSL-BAS-EVAL:MHA-BAS_TLE987x_v1.3.0-PR 1.3.0, TLE987x-eSL-BAS-EVAL:MS-BAS_TLE987x_v1.3.0-PR 1.3.0, TLE987x-eSL-BAS-EVAL:Math-BAS_TLE98xx_v1.3.0-PR 1.3.0
